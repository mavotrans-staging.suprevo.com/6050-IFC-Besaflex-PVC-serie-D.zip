Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2023-03-27T10:24:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 27 10:24:06 2023 * Host: MAV-DTP-TESSA * Database: C:\Users\T6FAF~1.PLA\AppData\Local\Temp\{9D0409DE-19F0-471B-95A7-7BEDB932AEC6}\ifc * Database version: 5507 * Database creation date: Mon Mar 27 10:24:05 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 27 10:24:05 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 27 10:24:05 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\5. Waterkerende materialen\60-Voegenbanden; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\5. Waterkerende materialen\60-Voegenbanden; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: NLRSnl_28_GM_WPB_6050-Besaflex PVC serie D_Mavotrans_R19:605032_Besaflex PVC D320, 605032
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - a (mm): 320 mm; b (mm): 110 mm; c (mm): 5 mm; f (mm): 15 mm; k (mm): 20 mm; Type: D320
Type - Fire Protection - Brandklasse | Fire classification: Niet getest | Not rated
Type - General - Rol lengte | Roll length: 25 m1
Type - Identity Data - Artikelnummer | Article number: 605032; Beschrijving | Description: Besaflex PVC D320; Laatste versie | Last version: 10-03-2023; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28; Opmerkingen | Comments: Voegenbanden voor stortnaden, binnenliggend | Joint tapes for construction joints, inside; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 605032_Besaflex PVC D320; URL: https://mavotrans.nl/besaflex-pvc-serie-d.html; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Soepel PVC, het materiaal is zuur- en loogvast, verrottingsbestendig en bestand tegen alle natuurlijke invloeden |Flexible PVC, the material is acid and lye resistant, rot resistant and resistant to all natural influences
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_WPB_6050-Besaflex PVC serie D_Mavotrans_R19
Type - Visibility - Besaflex PVC D120: no; Besaflex PVC D150: no; Besaflex PVC D200: no; Besaflex PVC D240: no; Besaflex PVC D320: yes; Besaflex PVC D350: no; Besaflex PVC D500: no
Type - Pset_ProductRequirements - Category: Generic Models
Description: Besaflex PVC D320; Classification: 28 (Default Classification)
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_WPB_6050-Besaflex PVC serie D_Mavotrans_R19:605032_Besaflex PVC D320; sets with these values: 2
Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 2.68034 m2; Lengte | Length (mm): 1000 mm; Volume: 0.0104343 m3
Other - Family: NLRSnl_28_GM_WPB_6050-Besaflex PVC serie D_Mavotrans_R19: 605032_Besaflex PVC D320; Family and Type: NLRSnl_28_GM_WPB_6050-Besaflex PVC serie D_Mavotrans_R19: 605032_Besaflex PVC D320; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_WPB_6050-Besaflex PVC serie D_Mavotrans_R19: 605032_Besaflex PVC D320; Type Id: NLRSnl_28_GM_WPB_6050-Besaflex PVC serie D_Mavotrans_R19: 605032_Besaflex PVC D320
Phasing - Phase Created: New Construction
